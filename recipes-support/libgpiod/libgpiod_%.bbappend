PACKAGECONFIG_append = "tests"
